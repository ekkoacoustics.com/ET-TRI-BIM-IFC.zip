Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Tri\ET-TRI-R-6060-24-000 TRI.IFC
Time: 2024-11-25T11:03:42+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 4.2794430139277138; Volume Measure: 0.0042794430139277; Area Measure: 0.7595202682606580

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 4.2794430139277138; Volume Measure: 0.0042794430139277; Area Measure: 0.7595202682606580

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 4.2794430139277138; Volume Measure: 0.0042794430139277; Area Measure: 0.7595202682606580

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ET-TRI-R-6060-24-000 TRI | PSet_Mass_Property - Mass Measure: 4.2794430139277138; Volume Measure: 0.0042794430139277; Area Measure: 0.7595202682606580
ET-TRI-R-6060-24-000 TRI
