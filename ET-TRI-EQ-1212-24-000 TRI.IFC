Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Tri\ET-TRI-EQ-1212-24-000 TRI.IFC
Time: 2024-11-25T11:04:23+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 14.9334219968451656; Volume Measure: 0.0149334219968452; Area Measure: 2.5737429731021546

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 14.9334219968451656; Volume Measure: 0.0149334219968452; Area Measure: 2.5737429731021546

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 14.9334219968451656; Volume Measure: 0.0149334219968452; Area Measure: 2.5737429731021546

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ET-TRI-EQ-1212-24-000 TRI | PSet_Mass_Property - Mass Measure: 14.9334219968451656; Volume Measure: 0.0149334219968452; Area Measure: 2.5737429731021546
ET-TRI-EQ-1212-24-000 TRI
