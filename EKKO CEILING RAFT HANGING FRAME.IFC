Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Tri\EKKO CEILING RAFT HANGING FRAME.IFC
Time: 2024-11-25T11:06:40+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 0.3524085269939360; Volume Measure: 0.0001305216766644; Area Measure: 0.1376431356366930

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 0.3524085269939360; Volume Measure: 0.0001305216766644; Area Measure: 0.1376431356366930

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 0.3524085269939360; Volume Measure: 0.0001305216766644; Area Measure: 0.1376431356366930

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EKKO CEILING RAFT HANGING FRAME | PSet_Mass_Property - Mass Measure: 0.3524085269939360; Volume Measure: 0.0001305216766644; Area Measure: 0.1376431356366930
EKKO CEILING RAFT HANGING FRAME
