Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Tri\ET-TRI-R-6060-24-000 TRI + GRIPPLE MINI CLUTCH + WIRE.IFC
Time: 2024-11-25T11:08:37+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 4.2969211907518812; Volume Measure: 0.0042969211907519; Area Measure: 0.7846546466518051

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 4.2969211907518812; Volume Measure: 0.0042969211907519; Area Measure: 0.7846546466518051

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 4.2969211907518812; Volume Measure: 0.0042969211907519; Area Measure: 0.7846546466518051

# IfcBuildingElementProxy (41)
In: default BuildingStorey
Name | Definition | Revision | Source | Part Number = Nomenclature | Description | sets with these values
ET-TRI-R-6060-24-000 TRI + GRIPPLE MINI CLUTCH + WIRE.SLDPRT | PSet_Mass_Property - Mass Measure: 4.2969211907518812; Volume Measure: 0.0042969211907519; Area Measure: 0.7846546466518051
Gripple_Mini_Angel Assembly
3 x Gripple_Mini_Angel | design | 1 | MADE | 218458_ASM | NOT SPECIFIED | 2
3 x Gripple_Mini_Angel.stp | design | 1 | MADE | 218458_ASM | NOT SPECIFIED | 2
3 x 218460_ASM.stp
3 x 145313.stp | design | 1 | MADE | 145313 | NOT SPECIFIED | 2
3 x 217899.stp | design | 1 | MADE | 217899 | NOT SPECIFIED | 2
3 x 145270.stp | design | 1 | MADE | 145270 | NOT SPECIFIED | 2
3 x 120377_ASM.stp
3 x 120374.stp | design | 1 | MADE | 120374 | NOT SPECIFIED | 2
3 x 120373.stp | design | 1 | MADE | 120373 | NOT SPECIFIED | 2
3 x 120376.stp | design | 1 | MADE | 120376 | NOT SPECIFIED | 2
3 x F000264 P50 Tensile Steel Wire 2m
3 x F000264 P50 Top Threaded Insert
Gripple_Mini_Angel Assembly-1
ET-TRI-R-6060-24-000 TRI
Gripple_Mini_Angel Assembly-2
