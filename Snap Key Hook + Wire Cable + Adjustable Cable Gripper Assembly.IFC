Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Tri\Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly.IFC
Time: 2024-11-25T11:07:54+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 0.0035263099649839; Volume Measure: 0.0000035263099650; Area Measure: 0.0042872710407440

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 0.0035263099649839; Volume Measure: 0.0000035263099650; Area Measure: 0.0042872710407440

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 0.0035263099649839; Volume Measure: 0.0000035263099650; Area Measure: 0.0042872710407440

# IfcBuildingElementProxy (3)
In: default BuildingStorey
Name
Snap Key Hook + Wire Cable + Adjustable Cable Gripper Assembly | PSet_Mass_Property - Mass Measure: 0.0035263099649839; Volume Measure: 0.0000035263099650; Area Measure: 0.0042872710407440
Snap Key Hook +Wire Cable+Cable Gripper | SOLIDWORKS Custom Properties - Nomenclature: hook lock; Part Number: hook lock; Source: NOT_KNOWN; Revision: ANY; sets with these values: 2
Wire Cable +Snap Key Hook
